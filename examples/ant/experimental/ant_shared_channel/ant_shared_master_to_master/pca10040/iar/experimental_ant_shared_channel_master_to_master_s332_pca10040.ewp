# IAR project experimental_ant_shared_channel_master_to_master_s332_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; BLE_STACK_SUPPORT_REQD; S332; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\..\components\softdevice\s332\headers; ..\..\..\..\..\..\..\components\softdevice\s332\headers\nrf52; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\components\toolchain\CMSIS\Include; ..\..\..\..\..\..\bsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: experimental_ant_shared_channel_master_to_master_s332_pca10040.hex
  ILINK.IlinkOutputFile: experimental_ant_shared_channel_master_to_master_s332_pca10040.out
  ILINK.IlinkIcfFile: experimental_ant_shared_channel_master_to_master_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/timer/: app_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_ANT
    ../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Board Support
    ../../../../../../bsp/: bsp.c
  group Application
    ../../: ant_phone_connection.c asc_coordinator.c asc_device_registry.c asc_master.c asc_master_to_master.c asc_pages.c ble_controllable_hub.c ble_phone_connection.c main.c n5sk_button.c n5sk_led.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_srv_common.c
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../../components/toolchain/: system_nrf52.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
