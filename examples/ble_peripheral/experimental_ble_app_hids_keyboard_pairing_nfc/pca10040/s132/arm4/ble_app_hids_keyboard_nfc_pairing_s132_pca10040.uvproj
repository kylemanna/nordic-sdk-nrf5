# Keil uVision project ble_app_hids_keyboard_nfc_pairing_s132_pca10040.uvproj, settings and files
target nrf58232_xxaa_s132 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf58232_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BSP_UART_SUPPORT NRF_LOG_USES_UART=1 SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fds\config;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\fstorage\config;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\connection_handover;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..\..\..\..\external\segger_rtt
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hids/: ble_hids.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gattc_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c sdk_mapped_flags.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_NFC
    ../../../../../../components/nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../../components/nfc/ndef/connection_handover/ac_rec/: nfc_ac_rec.c
    ../../../../../../components/nfc/ndef/connection_handover/: nfc_ble_pair_msg.c
    ../../../../../../components/nfc/ndef/connection_handover/ep_oob_rec/: nfc_ep_oob_rec.c
    ../../../../../../components/nfc/ndef/connection_handover/hs_rec/: nfc_hs_rec.c
    ../../../../../../components/nfc/ndef/connection_handover/le_oob_rec/: nfc_le_oob_rec.c
    ../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../components/nfc/t2t_lib/: nfc_t2t_lib_keil.lib
    ../../../../../../components/nfc/ndef/text/: nfc_text_rec.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
target flash_s132_nrf52_2.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: ..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
