# Keil uVision project ble_ant_app_hrm_s332_pca10040.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT TRACE_HRM_GENERAL_ENABLE TRACE_HRM_PAGE_0_ENABLE TRACE_HRM_PAGE_1_ENABLE TRACE_HRM_PAGE_2_ENABLE TRACE_HRM_PAGE_3_ENABLE TRACE_HRM_PAGE_4_ENABLE BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S332 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF_LOG_USES_UART=1
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\ant\ant_channel_config;..\..\..\..\..\..\components\ant\ant_key_manager;..\..\..\..\..\..\components\ant\ant_key_manager\config;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages\logger;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\utils;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\fstorage\config;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s332\headers;..\..\..\..\..\..\components\softdevice\s332\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..\..\..\..\external\segger_rtt
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0x59000
  memory RVCT9: RAM 0x20003800 size 0xc800
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../../../../../../components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../../../../../../components/ant/ant_key_manager/: ant_key_manager.c
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
