# IAR project esb_low_power_prx_blank_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; ESB_PRESENT; NRF_LOG_USES_RTT=1; NRF52
  ICCARM.CCIncludePath2: ..\..\..\config\esb_low_power_prx_blank_pca10040; ..\..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\properitary_rf\esb; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\CMSIS\Include; ..\..\..\..\..\bsp; ..\..\..; ..\..\..\..\..\..\external\segger_rtt
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: esb_low_power_prx_blank_pca10040.hex
  ILINK.IlinkOutputFile: esb_low_power_prx_blank_pca10040.out
  ILINK.IlinkIcfFile: esb_low_power_prx_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_log.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
  group Application
    ../../../: main.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_Properitary_RF
    ../../../../../../components/properitary_rf/esb/: nrf_esb.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
