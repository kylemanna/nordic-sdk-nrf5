# Keil uVision project gzp_host_dynamic_pairing_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10028 GAZELL_PRESENT BSP_DEFINES_ONLY NRF51
  c include: ..\..\..\config\gzp_host_dynamic_pairing_pca10028;..\..\..\config;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\properitary_rf\gzll;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\bsp;..\..\..
  asm define: BOARD_PCA10028 GAZELL_PRESENT BSP_DEFINES_ONLY NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main_host_dynamic_pairing.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group nRF_Libraries
    ../../../../../../../components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/gzll/arm/: gzll_arm.lib
    ../../../../../../../components/properitary_rf/gzll/: nrf_gzp.c nrf_gzp_host.c nrf_gzp_host_nrf51.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
