# IAR project adafruit_tag_reader_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ENABLE_DEBUG_LOG_SUPPORT; T2T_PARSER_ENABLE; NDEF_PARSER_LOG_ENABLE; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; NRF52; SWI_DISABLE0; NRF_LOG_USES_UART=1
  ICCARM.CCIncludePath2: ..\..\config\adafruit_tag_reader_pca10040; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\toolchain\CMSIS\Include; ..\..\..\..\bsp; ..\..; ..\..\..\..\..\external\nfc_adafruit_library; ..\..\..\..\..\external\segger_rtt
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adafruit_tag_reader_pca10040.hex
  ILINK.IlinkOutputFile: adafruit_tag_reader_pca10040.out
  ILINK.IlinkIcfFile: adafruit_tag_reader_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/trace/: app_trace.c
    ../../../../../components/nfc/ndef/parser/message/: nfc_ndef_msg_parser.c nfc_ndef_msg_parser_local.c
    ../../../../../components/nfc/ndef/parser/record/: nfc_ndef_record_parser.c
    ../../../../../components/libraries/uart/: retarget.c
  group Third Parties
    ../../../../../external/nfc_adafruit_library/: adafruit_pn532.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../components/toolchain/: system_nrf52.c
  group nRF_NFC
    ../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../components/nfc/t2t_parser/: nfc_t2t_parser.c
