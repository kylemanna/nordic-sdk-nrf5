# Keil uVision project adafruit_tag_reader_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: DEBUG ENABLE_DEBUG_LOG_SUPPORT T2T_PARSER_ENABLE NDEF_PARSER_LOG_ENABLE BOARD_PCA10028 NRF51 SWI_DISABLE0 NRF_LOG_USES_UART=1
  c misc: --c99
  c include: ..\..\config\adafruit_tag_reader_pca10028;..\..\config;..\..\..\..\..\components\device;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\trace;..\..\..\..\..\components\libraries\uart;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..;..\..\..\..\..\external\nfc_adafruit_library;..\..\..\..\..\external\segger_rtt
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group Third Parties
    ../../../../../external/nfc_adafruit_library/: adafruit_pn532.c
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/trace/: app_trace.c
    ../../../../../components/nfc/ndef/parser/message/: nfc_ndef_msg_parser.c nfc_ndef_msg_parser_local.c
    ../../../../../components/nfc/ndef/parser/record/: nfc_ndef_record_parser.c
    ../../../../../components/libraries/uart/: retarget.c
  group nRF_NFC
    ../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../components/nfc/t2t_parser/: nfc_t2t_parser.c
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
