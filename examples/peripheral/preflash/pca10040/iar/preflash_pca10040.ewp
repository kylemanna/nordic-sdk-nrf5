# IAR project preflash_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _value; _attrs; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; NRF_LOG_USES_UART=1; NRF52; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\components\nfc\t2t_lib\hal_t2t; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\toolchain\CMSIS\Include; ..\..\..\..\bsp; ..\..; ..\..\..\..\..\external\segger_rtt
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: preflash_pca10040.hex
  ILINK.IlinkOutputFile: preflash_pca10040.out
  ILINK.IlinkIcfFile: preflash_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/trace/: app_trace.c
    ../../../../../components/libraries/led_softblink/: led_softblink.c
    ../../../../../components/libraries/low_power_pwm/: low_power_pwm.c
    ../../../../../components/libraries/uart/: retarget.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../components/toolchain/: system_nrf52.c
  group nRF_NFC
    ../../../../../components/nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../components/nfc/t2t_lib/: nfc_t2t_lib_iar.a
    ../../../../../components/nfc/ndef/uri/: nfc_uri_msg.c nfc_uri_rec.c
