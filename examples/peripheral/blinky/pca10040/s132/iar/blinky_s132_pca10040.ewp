# IAR project blinky_s132_pca10040.ewp, settings and files
configuration nrf52832_xxaa_s132 (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BSP_DEFINES_ONLY; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; S132; NRF52; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\..\config\blinky_s132_pca10040; ..\..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\CMSIS\Include; ..\..\..\..\..\bsp; ..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: blinky_s132_pca10040.hex
  ILINK.IlinkOutputFile: blinky_s132_pca10040.out
  ILINK.IlinkIcfFile: blinky_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
