# Keil uVision project blinky_s132_pca10036.uvproj, settings and files
target nrf52832_xxaa_s132 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD BSP_DEFINES_ONLY NRF52_PAN_24 NRF52_PAN_25 NRF52_PAN_26 NRF52_PAN_27 NRF52_PAN_28 NRF52_PAN_29 NRF52_PAN_30 NRF52_PAN_32 NRF52_PAN_33 NRF52_PAN_34 NRF52_PAN_35 NRF52_PAN_36 NRF52_PAN_37 NRF52_PAN_38 NRF52_PAN_39 NRF52_PAN_40 NRF52_PAN_41 NRF52_PAN_42 NRF52_PAN_43 NRF52_PAN_44 NRF52_PAN_46 NRF52_PAN_47 NRF52_PAN_48 NRF52_PAN_49 NRF52_PAN_58 NRF52_PAN_63 NRF52_PAN_64 NRF52_PAN_65 CONFIG_GPIO_AS_PINRESET BOARD_PCA10036 NRF52_PAN_1 NRF52_PAN_2 NRF52_PAN_3 NRF52_PAN_4 NRF52_PAN_7 NRF52_PAN_8 NRF52_PAN_9 NRF52_PAN_10 NRF52_PAN_11 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_16 NRF52_PAN_17 NRF52_PAN_20 NRF52_PAN_23 S132 NRF52 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config\blinky_s132_pca10036;..\..\..\config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x200013c8 size 0x6c38
  group Application
    ../../../: main.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
target flash_s132_nrf52_2.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: ..\..\..\config\blinky_s132_pca10036;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x200013c8 size 0x6c38
