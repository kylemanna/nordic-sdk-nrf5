# Keil uVision project saadc_pca10040.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52
  c misc: --c99
  c include: ..\..\config;..\..\..\..\..\components\device;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\libraries\uart;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/uart/: retarget.c
