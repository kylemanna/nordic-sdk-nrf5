# Keil uVision project rng_s130_pca10031.uvproj, settings and files
target nrf51422_xxac_s130 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10031 S130 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config\rng_s130_pca10031;..\..\..\config;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001870 size 0x6790
  group Application
    ../../../: main.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s130/doc/: s130_nrf51_2.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
