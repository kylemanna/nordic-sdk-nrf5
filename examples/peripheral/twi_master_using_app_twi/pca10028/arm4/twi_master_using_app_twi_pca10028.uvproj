# Keil uVision project twi_master_using_app_twi_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BOARD_PCA10028 NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\config\twi_master_using_app_twi_pca10028;..\..\config;..\..\..\..\..\components\device;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\twi;..\..\..\..\..\components\libraries\uart;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..
  asm define: BOARD_PCA10028 NRF51 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: lm75b.c main.c mma7660.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/twi/: app_twi.c
    ../../../../../components/libraries/uart/: retarget.c
