# Keil uVision project blinky_rtx_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0 __STACK_SIZE=1024 BSP_DEFINES_ONLY BOARD_PCA10028 NRF51 RTX
  c include: ..\..\config\blinky_rtx_pca10028;..\..\config;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..;..\..\..\..\..\external\rtx\include
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
  group Third Parties
    ../../../../../external/rtx/source/ARM/: RTX_CM0.lib
    ../../../../../external/rtx/port/: RTX_Conf_CM.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
